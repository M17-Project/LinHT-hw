# Repository M17-Project/LinHT-hw

File README.md:

# LinHT-hw

**Open-source, Linux-based, SDR handheld transceiver**

[![CC BY-NC-SA 4.0][cc-by-nc-sa-shield]][cc-by-nc-sa]

## What is LinHT?

**LinHT** is an open-source handheld **software-defined radio (SDR) transceiver**
built around a modern Linux System-on-Module and a true IQ RF front-end.

It is the **successor of the OpenHT project**, with focus on:

* simpler and more maintainable hardware,
* no FPGA in the signal path,
* tight integration with Linux, GNU Radio, and modern SDR tooling,
* long-term openness and hackability.

LinHT is developed by members of the [**M17 community**](https://m17project.org) and is intended primarily
for **radio amateurs, SDR experimenters, and developers**.

This repository contains the **hardware design files** for LinHT.

> 📅 **October 2026 status**<br>
> A test batch of Rev C boards is being tested. Standby.<br>
> Rev C is the current development revision on `main`. It has not yet been
> tagged, or validated.<br>
> Rev B was manufactured and tested; the results are summarized in the
> [Rev B status report](https://m17project.org/2026/06/16/linht-rev-b-status-what-works-what-broke-and-why-rev-c-is-next/).<br>

> ⚠️ **Important**<br>
> LinHT is **not a consumer product** yet.<br>
> It is an experimental, community-driven open hardware project.

## Key ideas behind LinHT

* **True SDR**: IQ baseband access, not FM-only
* **Linux-first**: Linux runs the UI, DSP, and radio control; the ATtiny handles
  power sequencing
* **No FPGA**: easier development, lower entry barrier
* **Open everything**: hardware, software, toolchains
* **Hackable handheld**: not just another black box walkie-talkie

## Hardware overview

LinHT is built around a Linux SoM and a wideband IQ transceiver.

* **System on Module:** [CompuLab MCM-iMX93](https://www.compulab.com/products/computer-on-modules/mcm-imx93-nxp-i-mx-93-som-smd-system-on-module)
* **RF front-end:** [Semtech SX1255](https://www.semtech.com/products/wireless-rf/lora-core/sx1255)

**CPU**

* Dual-core ARM Cortex-A55 @ 1.7 GHz
* ARM Cortex-M33 coprocessor @ 250 MHz
* Floating-Point Unit
* ARM Ethos-U65 microNPU (TensorFlow Lite support)

**Memory**

* 2 GB LPDDR4
* 32 GB eMMC

### Main components

| Device | Role in LinHT | Main features |
| ------ | ------------- | ------------- |
| `MCM-iMX93-C1700D-D2-N32` | Linux System-on-Module | Dual Cortex-A55, Cortex-M33, 2 GB LPDDR4, 32 GB eMMC |
| `SX1255IWLTRT` | Direct-IQ RF front-end | Programmable UHF RX/TX signal chain with separate I/Q baseband paths |
| `GRF5604` | RF power amplifier | 100–600 MHz, 6 W class; about 4.5 W CW measured on Rev B |
| 2× `PE4312C-Z` | Receive-path attenuation | 6-bit digital step attenuator, 0.5 dB steps, 31.5 dB range per device |
| `SKY13330-397LF` | RF TX/RX switching | SPDT RF switch covering 0.1–6.0 GHz |
| `TLV320AIC3100IRHBR` | Audio codec | Low-power codec with audio processing and mono Class-D speaker amplifier |
| `LG77LICMD` | GNSS receiver | Single-band, multi-constellation GPS, GLONASS, Galileo, BDS, and QZSS |
| `BQ25792RQMR` | USB-C battery charger and power path | Buck-boost charger for the 2S battery, I2C control and telemetry |
| `ATtiny826-MU` | Always-on power-management controller | Rail sequencing, button handling, boot-mode control, and shutdown coordination |
| `TPS565242DRLR` | Main 5 V supply | 5 A synchronous step-down converter |

### RF capabilities

The values below describe the tested Rev B hardware and the current Rev C
design. Rev C retains the same main RF chain but must be measured again after
manufacturing.

| Parameter       | Value                                                         |
| --------------- | ------------------------------------------------------------- |
| Frequency range | **UHF band** (exact limits depend on PA/filter configuration) |
| Bandwidth       | up to **500 kHz IQ**                                          |
| Architecture    | Direct IQ (complex baseband)                                  |
| TX power        | about **4.5 W CW** measured on Rev B; around 3.5 W during an M17 test |
| RX features     | Two programmable step attenuators and gain control             |
| Modes           | FM, SSB, M17, experimental digital modes                      |

> 📌 **UHF only!**<br>
> VHF is not supported by the current hardware revisions.
> The current priority is **stability, manufacturability, and software maturity**.

## Software overview

LinHT runs a **custom Yocto-based Linux distribution** designed for SDR and
embedded radio use.

### Supported development models

* C / C++
* Python
* GNU Radio flowgraphs
* SoapySDR
* Custom DSP pipelines

Standard Linux tools (gcc, gdb, strace, etc.) are available directly on the device.

### Supported modes

This list reflects software and hardware work demonstrated with Rev A and Rev B.
Rev C hardware has not yet been tested.

* ✅ FM (TX/RX) with pre-/de-emphasis and CTCSS
* ✅ SSB (TX/RX)
* ✅ **M17** (TX/RX)
* ✅ TETRA (RX only)
* 🧪 Experimental 64-QAM @ 2 Mbps
* ⏳ Planned / possible: FreeDV, APRS, packet radio, custom modulations

## Hardware revisions

LinHT is developed iteratively. Each revision serves a specific purpose.

| Revision   | Status                                        | Purpose                                      |
| ---------- | --------------------------------------------- | -------------------------------------------- |
| **Rev. A** | Completed | Architecture proof of concept |
| **Rev. B** | Completed | Integrated feature prototype and system testing |
| **Rev. C** | In development (`main`), being tested | Targeted corrections based on Rev B testing |

See the [project changelog](CHANGELOG.md) for the changes introduced by each
hardware revision.

## Repository contents

This repository contains:

* KiCad 10.0 project files
* Schematics
* PCB layout
* Manufacturing outputs (generated automatically)

Gerbers, BOM, pick-and-place files, and schematics are:

* generated automatically via **GitHub Actions**
* published on [**GitHub Pages**](https://m17-project.github.io/LinHT-hw/)

Generated outputs follow the current `main` branch and therefore currently
represent the unvalidated Rev C design. Use the `revA` and `revB` Git tags for
historical revision snapshots.

## Required hardware (donor radio)

LinHT is designed as a **replacement mainboard** for the
**Retevis C62 handheld radio**. You will need:

* a Retevis C62 (donor device)
* its:
    * enclosure
    * display
    * keypad
    * battery
    * side-button PCB
    * SMA connector and audio jacks
    * rotary encoder, springs, and mechanical hardware

More details (Rev. A focused, older but useful): [LinHT Open SDR Handheld For Radio Amateurs](https://uart.cz/2811/linht-open-sdr-handheld-for-radio-amateurs/)

## Firmware images

Prebuilt Linux images for LinHT are available here:
[https://m17project.org/linht/](https://m17project.org/linht/)

Documentation:

* [https://wiki.m17foundation.org/index.php?title=LinHT_Image_Build](https://wiki.m17foundation.org/index.php?title=LinHT_Image_Build)

Yocto layers:

* [meta-linht-hardware](https://github.com/M17-Project/meta-linht-hardware)
* [meta-linht-software](https://github.com/M17-Project/meta-linht-software)
* [meta-linht-sdr](https://github.com/M17-Project/meta-linht-sdr)

## Flashing the device

Flashing is done using **NXP Universal Update Utility (uuu)**.

The intended Rev C workflow is to hold the secondary side button while powering
on. The ATtiny then requests USB boot from the SoM through the corrected
level-domain interface. This Rev C workflow has not yet been validated on
manufactured hardware.

Rev B cannot use the side-button USB-boot function reliably. Its ATtiny firmware
disables that behavior; development boards are flashed by interrupting U-Boot
over the Kenwood connector and running `ums 0 mmc 0`, or by manually driving the
SoM `USB_BOOT` input. See the
[Rev B status report](https://m17project.org/2026/06/16/linht-rev-b-status-what-works-what-broke-and-why-rev-c-is-next/)
for the hardware background.

Once the board is in USB boot mode, flash it using:

```bash
uuu -v -b emmc_all imx-boot-mcm-imx93-sd.bin-flash_singleboot linht-image-mcm-imx93.rootfs.wic.zst
```

Tool download: [mfgtools](https://github.com/nxp-imx/mfgtools/releases)

To access LinHT’s USB network device on Windows, install the **RNDIS driver**: [microsoft.com USB RNDIS Gadget](https://www.catalog.update.microsoft.com/Search.aspx?q=USB%20RNDIS%20Gadget)

## Documentation & Wiki

Primary documentation lives on the **M17 Wiki**:

* [LinHT overview](https://wiki.m17foundation.org/index.php?title=LinHT)
* [Image build instructions](https://wiki.m17foundation.org/index.php?title=LinHT_Image_Build)
* [Image usage & manual](https://wiki.m17foundation.org/index.php?title=LinHT_Image_Manual)

## Contributing

LinHT is a **community project** and contributions are welcome. The best way to
get involved is [**joining the M17 Discord**](https://discord.gg/4brEP8wwVp), look for channel: **#linht**.

This is the preferred place to:

* discuss ideas,
* coordinate work,
* ask questions,
* avoid duplicated effort.

Other ways to contribute:

* Open issues in this repository (design notes, questions, suggestions)
* Help on the **software side** (especially welcome):
    * Yocto recipes
    * device tree improvements
    * CI / GitHub Actions
    * build automation
* Explore and extend [LinHT-utils](https://github.com/M17-Project/LinHT-utils)

If you’re an experienced **embedded Linux or SDR developer**, we would love
your help.

## FAQ – Frequently Asked Questions

### ❓ Where can I buy LinHT hardware?

You currently **cannot buy LinHT as a product**. To build LinHT, you need to:

* manufacture the PCB yourself (using provided Gerbers),
* source components,
* assemble the board,
* reuse the parts listed under [Required hardware](#required-hardware-donor-radio)
  from a **Retevis C62** donor radio.

This may change in the future.

### ❓ Is LinHT suitable for everyday radio use?

Not yet. And maybe never in the "consumer radio" sense. LinHT is currently best
suited for:

* developers,
* radio amateurs comfortable with Linux,
* SDR experimenters,
* people who enjoy building and debugging hardware.

You should **not** expect:

* plug-and-play user experience,
* polished UI,
* certification,
* warranty,
* commercial-grade RF compliance.

### ❓ Does LinHT support VHF?

**No. The current LinHT hardware revisions are UHF-only.**

VHF support is a **frequently requested feature**, but it is
not currently planned. Adding another band significantly increases:

* RF complexity,
* filtering requirements,
* PCB area,
* development time.

Right now, the project is focused on:

* manufacturing and validating Rev C,
* improving software and DSP,
* validating the RF chain, power management, audio, and GNSS integration.

VHF is **not ruled out** for future revisions, but it is
**not a current priority**.

### ❓ Is LinHT certified / legal to transmit with?

LinHT itself is **not certified**. Responsibility lies with the builder and
the operator. LinHT is intended primarily for:

* amateur radio use,
* experimental licenses,
* lab and research environments.

Always follow your local radio regulations.

### ❓ I want to help. Where do I start?

The best starting point is **discussion**. Join the M17 Discord, channel: **#linht**.

Good ways to contribute:

* software development (Yocto, drivers, tooling),
* testing and feedback,
* documentation,
* RF/DSP experiments,
* CI and automation improvements.

If you’re unsure where to help - just ask.

## License

This project is licensed under: **Creative Commons Attribution-NonCommercial-ShareAlike 4.0 International**

You are free to:

* share
* adapt

Under the conditions:

* attribution
* non-commercial use
* share alike

[![CC BY-NC-SA 4.0][cc-by-nc-sa-image]][cc-by-nc-sa]

## Acknowledgements

LinHT is developed by the **M17 community**, with contributions from many individuals.
Thanks to everyone testing prototypes, reviewing schematics, writing software, and sharing ideas.

[cc-by-nc-sa]: http://creativecommons.org/licenses/by-nc-sa/4.0/
[cc-by-nc-sa-image]: https://licensebuttons.net/l/by-nc-sa/4.0/88x31.png
[cc-by-nc-sa-shield]: https://img.shields.io/badge/License-CC%20BY--NC--SA%204.0-lightgrey.svg

## KiCad design side-pcb/side-pcb.kicad_pcb

File side-pcb/README.md:

# LinHT Side Buttons

A small side PCB for the [LinHT](https://github.com/M17-Project/LinHT-hw)
handheld transceiver, carrying the two side buttons (PTT area) of the radio.

The board is soldered edge-on (perpendicularly) to the side of the LinHT main
PCB. Its outline matches the original side-button board of the **Retevis C62**
donor radio, so it fits the stock enclosure and rubber button covers without
modifications.

## Bill of Materials

Apart from the PCB itself you need:

* 2× metal button dome (snap dome), e.g.
  [AliExpress item 33001419494](https://www.aliexpress.com/item/33001419494.html)

The domes are placed over the exposed button contacts and held in place by
adhesive tape or the button membrane.

## Fabrication

Gerber files are generated by the CI and published on the
[LinHT hardware page](https://linht-radio.eu/), or can be exported
locally from `side-pcb.kicad_pcb` with KiCad 10.

Parts:
J1, J2, J3, J4, J5: Conn_01x01; TestPoint_Keystone_5015_Micro_Mini
SW1: PTT; linht-sidebtn
SW2: BTN; linht-sidebtn

Connections:
GND: J1.1 (Pin_1_1), J2.1 (Pin_1_1), J5.1 (Pin_1_1), SW1.2 (B), SW2.2 (B)
unnamed: J3.1 (Pin_1_1), SW1.1 (A)
unnamed: J4.1 (Pin_1_1), SW2.1 (A)

Board: 2 copper layers, 8.5 x 41.0 mm, 7 parts (5 on the bottom side), 3 nets.

## Commit log (part)

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2025-06-05 init push
2025-07-06 WIP SOM update
2025-07-09 SOM pins update
2025-07-09 Changed USB-C power symbol from `+5V` to `VBUS`
2025-07-09 Added 5V DC/DC converter and 1S battery charger
    * Maximum expected power consumption: 3.2 W
    * Maximum output current from the DC/DC converter: 0.65 A
    * Recommended inductors: LPS3015 or LPS4012
    * The system is powered by the battery only when USB power is not present
    * The battery is charged from USB with a maximum current of 500 mA
2025-07-09 Updated credits
2025-07-10 PDF plot
2025-07-10 added missing mic path
2025-07-10 added Retevis C62 mainboard's photos for reference
2025-07-12 Added pinout for the som
2025-07-12 Updated ignored files, removed `fp-info-cache` from the repository
2025-07-12 Fixed wrong pin names `JPn`->`JDn` in the WM8960 symbol
2025-07-12 Added the audio input/output using WM8960
    * Replaced TAC5111 with WM8960.
    * Connected internal speaker and headphone output.
    * Added JACK_DETECK signal
    * Connected 2.5mm jack to the WM8960.
    * Added SAI3_MCLK to the SoM symbol.
2025-07-13 Added second step-down converter for 3.3 V
    * Second TPS562203-based converter for 3.3 V rail.
    * Changed inductors for a thinner variant 2.8 mm instead of 4.8 mm
    * Recommended inductors are SRN6028-4R7M or FNR6028S4R7MT
    * Removed 3.3V LDO output from the SoM
2025-07-13 date, pdf plot
2025-07-13 Changed PCB stackup from 2 to 4 layers
2025-07-13 Added 3D models for USB-C and QFN-140 footprints
2025-07-14 Fixed MCM-iMX93 footprint per manufacturer design
    * Added G1-G24 pads to the symbol, assigned GND signal
    * Changed footprint per manufacturers specs
    * Renamed the footprint from QFN-140 to MCM-iMX93
    https://www.compulab.com/products/computer-on-modules/mcm-imx93-nxp-i-mx-93-som-smd-system-on-module/#devres
2025-07-14 Updated MCM-iMX93 symbol in the schematics
2025-07-14 Added 3D model of the SRN6028 inductor series
2025-07-14 Changed all EOLs from Windows (CRLF) to Unix style (LF)
    Unix style end-of-lines is standard in KiCAD world:
    https://klc.kicad.org/general/g1/g1.7.html
2025-07-14 Added gitattributes to force Unix-style EOL
2025-07-14 Removed `.kicad_prl` from repository, it is in ignored files
2025-07-15 Added footprint and 3D model for the FPC connector
    * JUSHUO AFC01-S16FCA-00
    * LCSC C262665
2025-07-15 Added footprint and positions for the side keys (BTN2/PTT)
    * Pad footprint on the original PCB (Retevis C62) is 1.7x2.2 mm.
    * Side keys are mounted on a separate PCB soldered via 5 pads on
    the main PCB.
2025-07-15 Fixed pinout for the SoM
    * Added missing pin definitions in MCM-iMX93 symbol
    * Added information about the keyboard wiring
    * Assigned all signals to pins in the SoM
2025-07-15 Fixed constrains and board stackup based on PCBWay recommendations
2025-07-15 updates
    - updated the 5V line (diode connected sources - USB and DC/DC)
    - proposed a power on-off circuit based on a XNOR gate
    - reannotated the schematic
    - updated the PDF
2025-07-16 Assigned footprint and layout position of the 2.5 mm jack
2025-07-17 tweaked the power-on circuit
    - supplied the XNOR gate with 5V instead of 3.3V
    - added a MOSFET to drive the 3.3V DC/DC converter's EN pin
    - removed a pull-up resistor at the ON/OFF line
2025-07-17 minor power on/off circuit tweaks
2025-07-18 Added footprint and 3D model for the BT-003 battery connector
2025-07-18 Assigned footprint and layout position of the battery connector
2025-07-19 Added VOL_ADC, ON/OFF_SW, fixed typo
2025-07-21 re-arranged the schematic at "root"
2025-07-22 Assigned USB and RF netclasses
    Two new netclasses are:
    * USB for differential USB pair
    * RF for any trace with 50 Ohm impedance
2025-07-22 Added solder pads (spring contacts) for GND and SPEAKER
2025-07-22 Added footprint of the SMA connector
    The SMA connector is the original one used in Retevis C62. Dimensions
    are based on measurements of the real part.
2025-07-23 Added footprint and symbol for the on/off switch with a potentiometer
2025-07-23 New footprint for the 20 pin display connector
2025-07-23 Connected display pins 6-12 and 14 to the GND
    Based on the original Retevis C62 PCB, these pins are grounded.
2025-07-24 Assigned missing footprints
2025-07-24 Fixed MCM-iMX93 symbol, added pads G25-G28
2025-07-24 Fixed majority of ERC warnings and errors
2025-07-24 Changed R1-R4 footprints from 0603 to 0402
    Original footprint was a mistake.
2025-07-24 Fixed minor schematic issues
2025-07-24 Added USB netclass to the USB traces near SoM
2025-07-24 Fixed 3D model path of the QFN50P500 footprint
2025-07-25 Swapped RF inputs of the BGS12P2L6 for better PCB routing
2025-07-25 Assigned RF_SW_CTRL signal to the pin 104 on SoM
2025-07-25 Changed resistor value for the volume to 15 kΩ
2025-07-25 Basic layout work (work-in-progress)
    * All parts positioned on the PCB.
    * Positions can and will change.
    * Basic routing.
2025-07-26 tiny changes
    - rearranged the `SWITCH_ON_OFF` connection on the root page slightly
    - updated the date
    - updated PDF render
2025-07-27 Connected battery voltage to the SoM ADC input
2025-07-27 Changed keyboard tracks to narrower netclass for easier layout
2025-07-27 Fixed pinout of the Kenwood connector and added RX/TX for debug
2025-07-27 Fixed footprint of the MCM-iMX93
    The pads had "paste" enabled but with negative offset making the paste
    layer zero size. Real "paste" was defined as a custom polygon.
    This commit fixes issues, leaving paste layer as per manufacturer's
    specification.
2025-07-27 Removed copper rectangle from the SMA footprint
2025-07-27 Added DRC exclusions and modified constrains
2025-07-27 Added series resistors to the `DEBUG_DEV_*` signals
2025-07-27 Changed MCLK audio signal for the 12.288 MHz oscillator
2025-07-28 Swapped signal names `RF_IN` and `RF_OUT`
2025-07-28 Fixed text about the "mounting holes"
2025-07-28 Fixed resistor R48 symbol to "small" version
    To keep resistor symbols consistent on the page.
2025-07-28 Added more GND vias
2025-07-28 Fixed PCB-edge/component clearance
    Some components were too close to the PCB edge where aluminum heat-sink
    is located.
2025-07-28 Fixed board edge and position of 3.5 mm jack
    The 3.5 mm jack footprint from the standard KiCAD library had to be
    modified. The PCB edge was moved 0.85 mm outward to match the C62
    connector and PCB layout.
2025-07-28 added a few more GND vias
2025-07-29 Added M17 logo and authors to the PCB's silkscreen
2025-07-29 Reorganized silkscreen text
2025-07-29 Updated PCB from schematics
2025-07-29 BOM update
    - changed the case of 74AHC1G86
    - R23 changed to 133k
    - pdf render
2025-07-31 Basic Github Actions for the web deploy
2025-07-31 Fixed formatting in README.md
2025-08-02 Fixed Markdown formatting in README
2025-08-05 readme update
2025-08-06 Update README.md
    Added link to the Wiki entry for build environment setup
    Added links to yocto layer repos and a short summary
2025-08-08 generate .vrml.gz file
2025-08-08 moved gzip call
2025-08-08 Added vrml viewer
2025-08-08 added viewer-js
2025-08-09 Added image, flashing and driver docs
2025-09-09 Added F&S iMX93 SoM symbol, footprint and 3D model
    This was imported from the manufacturer's Altium symbol and footprint.
2025-09-09 [WIP] F&S iMX93 OSM-FS Pinout
2025-09-14 Update README.md
    removed unnecessary space
2025-09-15 Removed 22 Ohm resistors on USB data lines
    These are not needed as per manufacturer's documentation.
    Fixes #25
2025-09-15 Fixed wrong pinout on the 3.5 mm jack
    RX signal is on the same pin as PTT on the Kenwood style connector.
    This is used by many HT manufacturers, so for example Baofeng programming
    cable can be used to connect to the debug UART of LinHT.
    Fixes #31
2025-09-16 Added a 1.8 V LDO for the digital IOs
    This simple LDO will serve as a powersource for the audio codec and
    any other IC with 1.8V IOVCC.
2025-09-17 Modified LCSC attributes
2025-09-17 Improved schematics readability
2025-09-17 Updated parameters of the 5V power rail
2025-09-23 Added SKY13330-397LF symbol, footprint and 3D model
2025-09-23 Changed revision to "B" and updated dateof the project
2025-09-23 [WIP] Added an RF PA based on GRF5604
    Fixes #27
2025-09-23 Added two series attenuators PE4312 to the RF input path
2025-09-30 Added symbol, footprint and 3D model of BQ25792 IC
2025-09-30 Footprint and 3D model of TDK's SPM6530 inductor
2025-09-30 WIP power on/off control
2025-10-03 Updated Coilcraft 0908SQ footprint and added 3D model
2025-10-03 Fixed and added LCSC reference numbers for all components
2025-10-08 Removed unused components, connected power signals to the SoM
2025-10-22 Fixed BQ25792 foorptint based on the manufacturer's specs
2025-10-22 Added missing courtyard to the `SLO0520H1R0` footprint
2025-10-23 Fixed missing GND for the RF PA output filter
2025-11-04 Removed battery voltage divider and `U_BATT_MON` signal to SoM
    Battery voltage can and will be measured by the BQ25792RQ IC via I2C
    register.
2025-11-04 [WIP] do-no-merge, PCB work
2025-11-04 updated RF attenuator symbol
2025-11-05 Fixed C60 position at the `VOL_POT`
2025-11-05 Added an RF PA based on GRF5604
    Fixes #27
    Fixes #28
2025-11-13 Added TPS565242 symbol
2025-11-13 Changed GPIO for the jack detect signal to pin 49
2025-11-13 Changed 5V DC/DC buck to TPS565242
    Original buck has 2 A maximum current output. New one has up to 5 A.
    Our design needs ~3 A maximum current.
    Fixes #38
2025-11-13 Changed LED resistors from 220R to 100R
    Fixes #37
2025-11-13 Minor schematics tweaks and pinout optimizations
2025-11-14 Removed 4 series resistors from the attenuators SPI lines
2025-11-14 Connected attenuator data signals to SoM and minor changes to SoM pinout
    KBD_PWM from 105 -> 95 (GPIO2_IO[25])
    RF_SW_CTRL from 104 -> 103 (GPIO2_IO[15])
    RF_ATT_DATA to 107 (SPI7_SOUT)
    RF_ATT_CLK to 106 (SPI7_SCK)
    RF_ATT_LE1 to 105 (GPIO2_IO[12])
    RF_ATT_LE2 to 104 (GPIO2_IO[13])
2025-11-25 Fixed capacitors for the BQ25792
2025-11-25 Update issue date and revision number
2025-11-26 Update pinout documentation based on revision B
2025-11-26 Add GNSS chip antenna ANT8010LL05R1516A
2025-11-26 Add LG77L GNSS module to the schema
2025-11-26 Add GNSS module PCB layout
2025-11-28 Add PPTC fuse to the battery
2025-12-01 Add `RF_PA_ENABLE` signal and MOSFETs to enable GRF5604
2025-12-01 Minor layout tweaks
2025-12-01 Fixed LG77L Mouser and LCSC part numbers
2025-12-01 Populate 10kOhm resistor simulating a battery thermistor
2025-12-01 Add "part number" column to the BOM export
2025-12-02 Remove whitespaces in PN and MPN fields
2025-12-02 Add quantity column to the csv BOM file
2025-12-03 Update "issue date" in the whole project
2025-12-03 Add SoM MCM-iMC93 into the BOM
2025-12-03 Remove old PDF schematic file
2025-12-04 Add SoM part number to the PN field
2025-12-08 Fixed GNSS TX/RX mixup and several ERC issues
2025-12-08 Fixed wrong `RF_ATT_*` pins direction
2025-12-08 Fixed GND keepout in the RF traces and added more GNS vias
2025-12-15 Export both side to the POS file
2025-12-15 Update readmewith more up-to-date info
2025-12-15 Fix PCB edge discontinuity error
2025-12-15 Panelize PCB before making fabrication files
    KiKit plugin is used to make a frame with Vcuts and tooling holes around
    the LinHT PCB.
2025-12-16 Fixed panelization params to be compliant with PCBWay and JLCPCB
    PCBWay needs 4 tooling holes of 2mm diameter
    JLCPCB needs minumum of 70x70 mm panel for Vcuts
2025-12-16 Fix formatting with HTML line breaks
    Unified formatting
2026-02-07 Create CNAME
2026-02-19 updates - Feb 2026
    Updated status for Revision B in README.
2026-02-19 Update README.md
    fixed a typo and added <br>
2026-02-28 Revise README with February 2026 status and improvements
    Updated the README to reflect the current status of Revision B PCBs and added details about major improvements.
2026-04-06 Update status date from March 2026 to April 2026
2026-05-03 Update README.md
    May 2026 status update.
